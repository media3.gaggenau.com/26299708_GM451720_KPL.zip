Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-20T10:31:24+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Zastępczy Interfejs Użytkownika 23.0.11.19

# IfcProject, 0001
LongName: Nazwa projektu; Phase: Stan projektu

# IfcSite, Default
RefLatitude: 52, 14, 59, 999999; RefLongitude: 20, 59, 59, 999999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
